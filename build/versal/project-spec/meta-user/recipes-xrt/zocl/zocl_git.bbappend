inherit externalsrc
EXTERNALSRC = "/scratch/predutta/XRT_clk_2/XRT_cr_clck_2/src/runtime_src/core/edge/drm/zocl"
EXTERNALSRC_BUILD = "/scratch/predutta/XRT_clk_2/XRT_cr_clck_2/src/runtime_src/core/edge/drm/zocl"
PACKAGE_CLASSES = "package_rpm"
LICENSE = "GPLv2 & Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=7d040f51aae6ac6208de74e88a3795f8"
